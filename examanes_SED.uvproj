# Keil uVision project examanes_SED.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C552 NXP
  cpu: IRAM(0-0xFF) CLOCK(30000000)
  output: examanes_SED
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: examen.c
